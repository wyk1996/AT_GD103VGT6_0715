# Keil uVision project project.uvprojx, settings and files
target rt-thread_gd32f103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103VG GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, GD32F10X_XD, RT_USING_ARM_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: 4G;.;applications;.;charge_pro;.;common;.;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\spi;..\..\components\drivers\include;..\..\components\drivers\spi\sfud\inc;..\..\components\drivers\include;packages\dlt645-latest\inc;packages\dlt645-latest\port;drivers;dwin;.;packages\EasyFlash-latest\inc;packages\fal-v0.5.0\inc;packages\fal-v0.5.0\samples\porting;..\..\components\finsh;.;..\..\include;..\..\components\libc\compilers\armlibc;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\nogcc;Libraries\CMSIS\GD\GD32F10x\Include;Libraries\CMSIS;Libraries\GD32F10x_standard_peripheral\Include;packages\rc522-latest;packages\rc522-latest\inc;user_lib;..\..\examples\utest\testcases\kernel;.\packages\agile_led-latest\examples;.\packages\agile_led-latest\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Applications
    applications/: main.c gd32f10x_it.c
    ./applications/: ATreadme-csh.txt
  group 4G
    4G/: APFrame.c YKCFrame.c 4GSend.c 4GMain.c HYFrame.c ModuleA7680C.c 4GRecv.c ZFFrame.c
  group charge_pro
    charge_pro/: chtask.c ch_in_io.c chproc.c ch_port.c cp.c rn8209.c
  group common
    common/: mq_service.c
  group CPU
    ../../libcpu/arm/common/: showmem.c div0.c backtrace.c
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../components/drivers/misc/: adc.c rt_drv_pwm.c pin.c
    ../../components/drivers/mtd/: mtd_nor.c
    ../../components/drivers/rtc/: rtc.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../components/drivers/spi/: spi_flash_sfud.c spi_core.c spi_dev.c
    ../../components/drivers/src/: completion.c ringblk_buf.c waitqueue.c dataqueue.c workqueue.c pipe.c ringbuffer.c
  group dlt645
    packages/dlt645-latest/port/: dlt645_port.c
    packages/dlt645-latest/src/: dlt645_1997.c dlt645.c dlt645_2007.c dlt645_data.c
  group Drivers
    drivers/: drv_gpio.c drv_spi.c drv_usart.c drv_i2c.c drv_spi_flash.c drv_rtc.c board.c
  group dwin
    dwin/: DispkeyFunction.c Dispkey.c DwinProtocol.c MenuDisp .c DispShowStatus.c dwin_com_pro.c
  group EasyFlash
    packages/EasyFlash-latest/src/: ef_log.c ef_env_legacy_wl.c easyflash.c ef_iap.c ef_env.c ef_cmd.c ef_utils.c ef_env_legacy.c
    packages/EasyFlash-latest/ports/: ef_fal_port.c
  group fal
    packages/fal-v0.5.0/src/: fal_flash.c fal_partition.c fal_rtt.c fal.c
    packages/fal-v0.5.0/samples/porting/: fal_flash_sfud_port.c fal_flash_gd32f10x_port.c
  group Finsh
    ../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../src/: timer.c thread.c mem.c kservice.c ipc.c object.c irq.c device.c clock.c scheduler.c mempool.c components.c idle.c
  group libc
    ../../components/libc/compilers/armlibc/: mem_std.c syscalls.c libc.c
    ../../components/libc/compilers/common/: stdlib.c time.c
  group Libraries
    Libraries/GD32F10x_standard_peripheral/Source/: gd32f10x_exti.c gd32f10x_usart.c gd32f10x_fmc.c gd32f10x_rtc.c gd32f10x_crc.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_dbg.c gd32f10x_fwdgt.c gd32f10x_adc.c gd32f10x_misc.c gd32f10x_i2c.c gd32f10x_bkp.c gd32f10x_pmu.c gd32f10x_dma.c gd32f10x_gpio.c gd32f10x_sdio.c gd32f10x_dac.c gd32f10x_timer.c gd32f10x_spi.c gd32f10x_can.c gd32f10x_wwdgt.c gd32f10x_rcu.c
    Libraries/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_xd.s
    Libraries/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group rc522
    packages/rc522-latest/examples/: read_nuid.c fix_brickeduid.c dunp_info.c firmware_check.c mifare_classic_value_block.c change_uid.c
    packages/rc522-latest/src/: mfrc522.c
    packages/rc522-latest/port/: mfrc522_rtt_stm32_port.c
  group user_lib
    user_lib/: timestamp.c crc.c user_lib.c
  group led
    ./packages/agile_led-latest/examples/: example_agile_led.c
    ./packages/agile_led-latest/src/: agile_led.c led_thread.c
